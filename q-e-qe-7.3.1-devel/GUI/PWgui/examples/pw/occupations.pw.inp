  
  
 &CONTROL
                       title = 'band structure of Al' ,
                restart_mode = 'from_scratch' ,
                      outdir = '/home/giannozz/tmp/' ,
                  pseudo_dir = '/home/giannozz/New-sesame/pseudo/' ,
                      prefix = 'al' ,
                   verbosity = 'default' ,
 /
 &SYSTEM
                       ibrav = 2,
                   celldm(1) = 7.5000000000,
                         nat = 1,
                        ntyp = 1,
                     ecutwfc = 15.0000000000 ,
                       nosym = .false. ,
                        nbnd = 8,
                 occupations = 'from_input' ,
 /
 &ELECTRONS
 /
ATOMIC_SPECIES
   Al   26.98000  Al.vbc.UPF 
ATOMIC_POSITIONS alat 
   Al      0.000000000    0.000000000    0.000000000    
K_POINTS tpiba 
28 
   0.000000000    0.000000000    0.000000000      1.000000000 
   0.000000000    0.000000000    0.100000000      1.000000000 
   0.000000000    0.000000000    0.200000000      1.000000000 
   0.000000000    0.000000000    0.300000000      1.000000000 
   0.000000000    0.000000000    0.400000000      1.000000000 
   0.000000000    0.000000000    0.500000000      1.000000000 
   0.000000000    0.000000000    0.600000000      1.000000000 
   0.000000000    0.000000000    0.700000000      1.000000000 
   0.000000000    0.000000000    0.800000000      1.000000000 
   0.000000000    0.000000000    0.900000000      1.000000000 
   0.000000000    0.000000000    1.000000000      1.000000000 
   0.000000000    0.000000000    0.000000000      1.000000000 
   0.000000000    0.100000000    0.100000000      1.000000000 
   0.000000000    0.200000000    0.200000000      1.000000000 
   0.000000000    0.300000000    0.300000000      1.000000000 
   0.000000000    0.400000000    0.400000000      1.000000000 
   0.000000000    0.500000000    0.500000000      1.000000000 
   0.000000000    0.600000000    0.600000000      1.000000000 
   0.000000000    0.700000000    0.700000000      1.000000000 
   0.000000000    0.800000000    0.800000000      1.000000000 
   0.000000000    0.900000000    0.900000000      1.000000000 
   0.000000000    1.000000000    1.000000000      1.000000000 
   0.000000000    0.000000000    0.000000000      1.000000000 
   0.100000000    0.100000000    0.100000000      1.000000000 
   0.200000000    0.200000000    0.200000000      1.000000000 
   0.300000000    0.300000000    0.300000000      1.000000000 
   0.400000000    0.400000000    0.400000000      1.000000000 
   0.500000000    0.500000000    0.500000000      1.000000000 
OCCUPATIONS
 2 2 2 2 2 2 2 2 2 2
 2 2 1 1 0 0 0











