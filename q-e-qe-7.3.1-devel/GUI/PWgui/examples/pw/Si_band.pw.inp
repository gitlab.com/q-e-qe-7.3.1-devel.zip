Si-bulk
band test
 &control
    calculation='nscf'
    pseudo_dir = '$PSEUDO_DIR/',
    outdir='$TMP_DIR/',
    prefix='silicon'
 &end
 &system    
	ibrav     =  2, 
	celldm(1) =  10.20, 
	nat       =  2, 
        ntyp      =  1,
        ecutwfc   =  18.0,
        nbnd      =  8,
 &end
 &electrons
 &end

ATOMIC_SPECIES
 Si  28.086  Si.vbc.UPF
ATOMIC_POSITIONS alat
 Si 0.00 0.00 0.00 
 Si 0.25 0.25 0.25 
K_POINTS tpiba
 28
   0.0 0.0 0.0 1.0
   0.0 0.0 0.1 1.0
   0.0 0.0 0.2 1.0
   0.0 0.0 0.3 1.0
   0.0 0.0 0.4 1.0
   0.0 0.0 0.5 1.0
   0.0 0.0 0.6 1.0
   0.0 0.0 0.7 1.0
   0.0 0.0 0.8 1.0
   0.0 0.0 0.9 1.0
   0.0 0.0 1.0 1.0
   0.0 0.0 0.0 1.0
   0.0 0.1 0.1 1.0
   0.0 0.2 0.2 1.0
   0.0 0.3 0.3 1.0
   0.0 0.4 0.4 1.0
   0.0 0.5 0.5 1.0
   0.0 0.6 0.6 1.0
   0.0 0.7 0.7 1.0
   0.0 0.8 0.8 1.0
   0.0 0.9 0.9 1.0
   0.0 1.0 1.0 1.0
   0.0 0.0 0.0 1.0
   0.1 0.1 0.1 1.0
   0.2 0.2 0.2 1.0
   0.3 0.3 0.3 1.0
   0.4 0.4 0.4 1.0
   0.5 0.5 0.5 1.0
