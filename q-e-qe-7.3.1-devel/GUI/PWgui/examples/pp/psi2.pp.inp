 &INPUTPP
                      prefix = 'pwscf' ,
                      outdir = './' ,
                     filplot = 'pwscf.plot' ,
                    plot_num = 7,
                      kpoint = 1,
                       kband = 14,
 /
 &PLOT
 /
