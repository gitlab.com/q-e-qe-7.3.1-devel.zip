2 1 3 
 &first
                v1 = 1 ,
                v2 = 2 ,
               v11 = 3 ,
               v12 = 4 ,
           t1(1,1) = 5,
           t1(1,2) = 6,
           t1(1,3) = 7,
           t1(1,4) = 8,
           t1(2,1) = 9,
           t1(2,2) = 10,
           t1(2,3) = 11,
           t1(2,4) = 12,
           dim1(1) = d11,
           dim1(2) = d12,
           dim1(3) = d13,
 &end
11 12 13 
21 22 23 
31 32 33 

a b c 
d e f 
 &second
                v3 = 1 ,
                v4 = 2 ,
           t2(1,1) = 3,
           t2(1,2) = 4,
           t2(1,3) = 5,
           t2(1,4) = 6,
           t2(2,1) = 7,
           t2(2,2) = 8,
           t2(2,3) = 9,
           t2(2,4) = 10,
           dim1(1) = 11,
           dim1(2) = 13,
           dim1(3) = 14,
 &end

