 &control
    title = 'SiH4' ,
    calculation = 'md' ,
    restart_mode = 'from_scratch' ,
    nstep  = 500,
    iprint = 10,
    isave  = 100,
    dt    = 3.0d0,
    disk_io = 'low' ,
    prefix = 'SiH4',
    pseudo_dir='/home/pizza/codes/QEdev/q-e/pseudo/',
    outdir='/home/pizza/codes/QEdev/q-e/tempdir/',
 /
 &SYSTEM
    ibrav = 0 ,
    celldm(1) = 8.0 ,
    nat = 5  ,
    ntyp = 2 ,
    ecutwfc = 20 ,
    ecutrho = 80 ,
    nextffield = 2,
    nosym = .TRUE.,
 /
 &ELECTRONS
    mixing_beta = 0.4,
    conv_thr =  1.0d-7,
 /
 &IONS 
    tempw = 300,
    ion_temperature = 'rescaling',
 /
CELL_PARAMETERS  alat
    1.000000000    0.000000000    0.000000000 
     0.000000000   1.000000000    0.000000000 
     0.000000000    0.000000000   1.000000000 
ATOMIC_SPECIES
   Si   28.08600  Si.pbe-hgh.UPF
    H    1.00000  H.pbe-hgh.UPF
ATOMIC_POSITIONS bohr
Si      0.94486306644282E+01     0.94486306644282E+01     0.945E+01
H      0.11193736563321E+02     0.11193736698874E+02     0.111E+02
H       0.94486306644282E+01     0.94486306644282E+01     0.66E+01
H      0.70648871385200E+01     0.10088581790695E+02     0.111E+02
H       0.10088581849053E+02     0.70648872790557E+01     0.111E+02
K_POINTS gamma
